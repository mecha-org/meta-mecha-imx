PACKAGECONFIG[wayland] = " "